# Keil uVision project Command.uvproj, settings and files
target Target 1 (MCS-51)
  device: MPC82G516A Megawin
  cpu: IRAM(0 - 0xFF) XRAM(0x0-0x3FF) IROM(0 - 0x3FFF) CLOCK(45000000)
  output: TW2835 +hex
  AfterMake: ML0700_Tw2835.bat
  c flags: Optimize=9 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 UART.c BusCtrl.c CommandShell.c Main.c OSD_Graph.c OSDAction.c OSDCtrl.c Timer.c TW28xx_Audio.c TW28xx_Video.c TW2835_Init.c monitor.c Printf.c
